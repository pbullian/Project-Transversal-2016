# Keil uVision project FO-M5.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: FO-M5
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Structures.h FO-M5_main.c FO-M5.c c8051F020.h FO-M5.h Declarations_GPIO_BSE.h
