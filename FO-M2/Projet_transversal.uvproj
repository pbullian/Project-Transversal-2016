# Keil uVision project Projet_transversal.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet_transversal
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LIB_BSE_INT_UART.c BSE_Main.c LIB_BSE_GPIO.c LIB_BSE_Config_Globale.c c8051F020.h LIB_BSE_Config_Globale.h LIB_BSE_GPIO.h LIB_BSE_UART.h serializer.c Structure.h UART1_RINGBUFFER_LIB.C UART1_RingBuffer_lib.h
