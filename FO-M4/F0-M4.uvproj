# Keil uVision project F0-M4.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: F0-M4
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BSE_Main.c LIB_BSE_ADC.c LIB_BSE_Config_Globale.c LIB_BSE_GPIO.c LIB_BSE_INT_Ext.c c8051F020.h Declarations_GPIO_BSE.h LIB_BSE_ADC.h LIB_BSE_Config_Globale.h LIB_BSE_GPIO.h LIB_BSE_INT_Ext.h
